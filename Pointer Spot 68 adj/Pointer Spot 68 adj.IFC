Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: Pointer Spot 68 adj.IFC
Time: 2024-08-30T13:54:01
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Pointer Spot 68 adj
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
